# Keil uVision project sdmmc_fat_sam_e70_xult_freertos_keil.uvprojx, settings and files
target sam_e70_xult_freertos_keil (6140000::V6.14::ARMCLANG)
  device: ATSAME70Q21B Microchip
  pack: Atmel.SAME70_DFP.2.4.166
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sam_e70_xult_freertos_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_e70_xult_freertos_keil;..\src\packs\ATSAME70Q21B_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS;.;..\src\config\sam_e70_xult_freertos_keil\system\fs\fat_fs\file_system;..\src\config\sam_e70_xult_freertos_keil\system\fs\fat_fs\hardware_access;..\src\third_party\rtos\FreeRTOS\Source\include;..\src\third_party\rtos\FreeRTOS\Source\portable\KEIL\CM7
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\src\config\sam_e70_xult_freertos_keil\sam_e70_xult_freertos_keil.sct
  group Harmony3
    ../src/config/sam_e70_xult_freertos_keil/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_e70_xult_freertos_keil/driver/sdmmc/src/: drv_sdmmc_local.h drv_sdmmc_file_system.c drv_sdmmc.c
    ../src/config/sam_e70_xult_freertos_keil/: device_cache.h toolchain_specifics.h definitions.h FreeRTOSConfig.h user.h configuration.h initialization.c interrupts.c exceptions.c startup_keil.c freertos_hooks.c tasks.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/clk/: plib_clk.h plib_clk.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/pio/: plib_pio.h plib_pio.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/xdmac/: plib_xdmac_common.h plib_xdmac.h plib_xdmac.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/efc/: plib_efc.h plib_efc.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/tc/: plib_tc0.h plib_tc_common.h plib_tc0.c
    ../src/config/sam_e70_xult_freertos_keil/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e70_xult_freertos_keil/system/time/src/: sys_time_local.h sys_time.c
    ../src/config/sam_e70_xult_freertos_keil/bsp/: bsp.h bsp.c
    ../src/config/sam_e70_xult_freertos_keil/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_e70_xult_freertos_keil/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
    ../src/config/sam_e70_xult_freertos_keil/system/fs/fat_fs/file_system/: ff.h ffconf.h ff.c ffunicode.c
    ../src/config/sam_e70_xult_freertos_keil/system/fs/fat_fs/hardware_access/: diskio.h diskio.c
    ../src/packs/ATSAME70Q21B_DFP/: device.h atsame70q21b.h
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/KEIL/CM7/: portmacro.h port.c
    ../src/config/sam_e70_xult_freertos_keil/peripheral/hsmci/: plib_hsmci_common.h plib_hsmci.h plib_hsmci.c
    ../src/config/sam_e70_xult_freertos_keil/driver/: driver.h driver_common.h
    ../src/config/sam_e70_xult_freertos_keil/system/: system.h system_common.h system_module.h system_media.h
    ../src/config/sam_e70_xult_freertos_keil/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_e70_xult_freertos_keil/system/cache/: sys_cache.h sys_cache.c
    ../src/config/sam_e70_xult_freertos_keil/osal/: osal.h osal_definitions.h osal_freertos.h osal_freertos.c
    ../src/: app.h main.c app.c
    ../src/config/sam_e70_xult_freertos_keil/system/debug/: sys_debug.h
    ../src/config/sam_e70_xult_freertos_keil/stdio/: keil_monitor.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_e70_xult_freertos_keil/system/int/src/: sys_int.c
